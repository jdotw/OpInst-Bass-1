File: PCB/Boom-1-Top/Rotary_Encoders.kicad_sch (KiCad schematic)
At the start: 373 parts

Commit message: Top: more splitting up done, still [WIP]
Parts:
- gave numbers to parts that had none: 373
